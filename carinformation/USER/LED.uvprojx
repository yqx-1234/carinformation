# Keil uVision project LED.uvprojx, settings and files
target LED (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\fourG;..\HARDWARE\mqtt;..\HARDWARE\usart1;..\HARDWARE\usart2;..\HARDWARE\HMAC\inc;..\HARDWARE\key;..\HARDWARE\tim3;..\HARDWARE\tim4;..\HARDWARE\commu;..\HARDWARE\led;..\HARDWARE\gcan600
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../HARDWARE/usart1/: usart1.c
    ../HARDWARE/usart2/: usart2.c
    ../HARDWARE/tim3/: timer3.c
    ../HARDWARE/tim4/: timer4.c
  group HARDWARE
    ../HARDWARE/mqtt/: mqtt.c
    ../HARDWARE/fourG/: fourG.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/commu/: commu.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/gcan600/: gcan600.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c
  group README
    ../: readme.txt
  group HMAC
    ../HARDWARE/HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
